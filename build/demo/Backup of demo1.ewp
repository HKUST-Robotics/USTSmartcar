# IAR project Backup of demo1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512
  ICCARM.CCIncludePath2: D:\project\src\cpu; D:\project\src\app; D:\project\src\drivers; D:\project\src\cpu\headers; D:\project\src\platforms; D:\project\src\common; D:\project\src\drivers\LED
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo1.hex
  ILINK.IlinkOutputFile: demo1.out
  ILINK.IlinkIcfFile: D:\project\build\config files\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCOptLevel: 3
configuration Flash (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: C:\Users\Ambi\Robotics\Smart Car\Program\project\src\cpu; C:\Users\Ambi\Robotics\Smart Car\Program\project\src\app; C:\Users\Ambi\Robotics\Smart Car\Program\project\src\drivers; C:\Users\Ambi\Robotics\Smart Car\Program\project\src\cpu\headers; C:\Users\Ambi\Robotics\Smart Car\Program\project\src\platforms; C:\Users\Ambi\Robotics\Smart Car\Program\project\src\common; C:\Users\Ambi\Robotics\Smart Car\Program\project\srcc\drivers\LED
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: C:\Users\Ambi\Robotics\Smart Car\Program\project\build\config files\512KB_Pflash.icf
  group app
    ../../src/app/: include.h isr.c isr.h main.c
  group common
    ../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
    ../../src/drivers/PIT/: PIT.c PIT.h
  group drivers
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/mcg/: Fire_kinetis_MCG_CFG.h mcg.c mcg.h mcg_cfg.h
    ../../src/drivers/FTM/: FTM.c FTM.h
    ../../src/drivers/: fuzzy.c fuzzy.h
    ../../src/drivers/gpio/: gpio.c gpio.h gpio_cfg.h
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c lptmr.h
    ../../src/drivers/uart/: uart.c uart.h
    ../../src/drivers/wdog/: wdog.c wdog.h
